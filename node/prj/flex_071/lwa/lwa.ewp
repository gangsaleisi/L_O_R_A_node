# IAR project lwa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L052R8 ST STM32L052R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L051xx; LOW_POWER_MODE_ENABLE; USE_BAND_915_HYBRID; TMP006; MODE_OTA; USE_DEBUGGER
  ICCARM.CCDiagSuppress: Pa050, Pa093
  ICCARM.CCIncludePath2: ..\..\..\src\app\common; ..\..\..\src\hal\mcu\cmsis; ..\..\..\src\hal\mcu\ST\stm32l0; ..\..\..\src\hal\flex_071; ..\..\..\src\lib\lorawan-node\src; ..\..\..\src\lib\lorawan-node\src\mac; ..\..\..\src\lib\lorawan-node\src\misc; ..\..\..\src\lib\lorawan-node\src\radio; ..\..\..\src\lib\lorawan-node\src\system; ..\..\..\src\lib\lorawan-node\src\system\crypto; ..\..\..\src\sensor; ..\..\..\src\stm32\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lwa.hex
  ILINK.IlinkOutputFile: lwa.out
  ILINK.IlinkIcfFile: stm32l052xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NDebug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L052xx; LOW_POWER_MODE_ENABLE; USE_BAND_868
  ICCARM.CCDiagSuppress: Pa050,Pa093
  ICCARM.CCIncludePath2: ..\..\..\src\app\common; ..\..\..\src\hal\mcu\cmsis; ..\..\..\src\hal\mcu\ST\stm32l0; ..\..\..\src\hal\rhf76-052; ..\..\..\src\lib\lorawan-node\src; ..\..\..\src\lib\lorawan-node\src\mac; ..\..\..\src\lib\lorawan-node\src\misc; ..\..\..\src\lib\lorawan-node\src\radio; ..\..\..\src\lib\lorawan-node\src\system; ..\..\..\src\lib\lorawan-node\src\system\crypto
  OBJCOPY.OOCOutputFile: lwa.srec
  group app
    ../../../src/app/common/: app-lm.c
    ../../../src/app/flex_071/lwa/: main.c
  group hal
    ../../../src/hal/flex_071/: board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c sys-irq.c timer-board.c uart-board.c
    ../../../src/hal/mcu/ST/stm32l0/iar/: startup_stm32l052xx.s
    ../../../src/hal/mcu/ST/stm32l0/: system_stm32l0xx.c
  group lib
    ../../../src/lib/lorawan-node/src/misc/: utilities.c
  group lib/lorawan-node
    ../../../src/lib/lorawan-node/src/system/crypto/: aes.c cmac.c
    ../../../src/lib/lorawan-node/src/system/: delay.c gpio.c timer.c
    ../../../src/lib/lorawan-node/src/mac/: LoRaMac-api-v3.c LoRaMac.c LoRaMacCrypto.c
    ../../../src/lib/lorawan-node/src/radio/sx1276/: sx1276.c
  group sensor
    ../../../src/sensor/: adc-board.c adc.c flash.c i2c.c sensor.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group stm32/src
    ../../../src/stm32/src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
