# Keil uVision project lwa.uvprojx, settings and files
target Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: lwa
  c flags: Optim=4 uC99=1
  c define: STM32L052xx USE_DEBUGGER LOW_POWER_MODE_ENABLE USE_BAND_868
  c include: ..\..\..\src\app\common;..\..\..\src\hal\mcu\cmsis;..\..\..\src\hal\mcu\ST\stm32l0;..\..\..\src\hal\rhf76-052;..\..\..\src\lib\lorawan-node\src;..\..\..\src\lib\lorawan-node\src\mac;..\..\..\src\lib\lorawan-node\src\misc;..\..\..\src\lib\lorawan-node\src\radio;..\..\..\src\lib\lorawan-node\src\system;..\..\..\src\lib\lorawan-node\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../../../src/app/common/: app-lm.c
    ../../../src/app/rhf76-052/lwa/: main.c
  group hal
    ../../../src/hal/rhf76-052/: board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c sys-irq.c timer-board.c
    ../../../src/hal/mcu/ST/stm32l0/: system_stm32l0xx.c
    ../../../src/hal/mcu/ST/stm32l0/arm/: startup_stm32l052xx.s
  group lib
    ../../../src/lib/lorawan-node/src/misc/: utilities.c
  group lib/lorawan-node
    ../../../src/lib/lorawan-node/src/mac/: LoRaMac.c LoRaMac-api-v3.c LoRaMacCrypto.c
    ../../../src/lib/lorawan-node/src/radio/sx1276/: sx1276.c
    ../../../src/lib/lorawan-node/src/system/: delay.c gpio.c timer.c
    ../../../src/lib/lorawan-node/src/system/crypto/: aes.c cmac.c
target NDebug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: lwa
  c flags: Optim=4 uC99=1
  c define: STM32L052xx LOW_POWER_MODE_ENABLE USE_BAND_868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
